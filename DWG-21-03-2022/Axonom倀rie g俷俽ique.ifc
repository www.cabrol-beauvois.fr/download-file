Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: Off], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: X:\AFFAIRES\21040-ECS_FALKOM-REVEL\21040-PHASES_ETUDES_&_CHANTIER\21040-3-APD-DPC\21040-APD\21040-APD-SORTIE\DWG-21-03-2022\Axonométrie générique.ifc
Time: 2022-03-21T14:47:33
Author: CABROL Benoît
Organization: Cabinet CABROL Architecture
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 25.0.0 FRA FULL Windows version (IFC add-on version: 4013 FRA FULL).
Authorization: CABROL Benoît

# IfcProject, Bâtiment Industriel FALKOM-ECS
Description: Bâtiment Industriel FALKOM-ECS

# IfcSite, Site
RefLatitude: 43, 34, 56, 100000; RefLongitude: 1, 20, 47, 0; RefElevation: 156.34 m

# IfcBuildingStorey (4)
In: Bâtiment
Name | Elevation (m)
-1. Étage | -0.5
0. Étage | 0
1. Étage | 2.8
2. Étage | 5.4

# IfcBuildingElementPart (5868)
Name | In | Material
25 x Struct. - B.A. coulé fondation | -1. Étage | Struct. - B.A. coulé fondation
50 x Struct. - B.A. coulé | -1. Étage | Struct. - B.A. coulé
125 x Métal - Strcuture métal | -1. Étage | Métal - Strcuture métal
58 x Structural 0/20 | -1. Étage | Structural 0/20
58 x Env. - Bitume BBME 0/10 | -1. Étage | Env. - Bitume BBME 0/10
Env. - Gravier | -1. Étage | Env. - Gravier
Béton balayer | -1. Étage | Béton balayer
3 x Finition int - Plaque de plâtre Doublage +1 | 0. Étage | Finition int - Plaque de plâtre Doublage +1
19 x Isolation - Laine de roche | 0. Étage | Isolation - Laine de roche
3 x Divers - Vide | 0. Étage | Divers - Vide
5 x Etanchéité - AEROBLUE | 0. Étage | Etanchéité - AEROBLUE
6 x Struct. - Brique creuse pour planelle | 0. Étage | Struct. - Brique creuse pour planelle
7 x Finition ext - Crépis blanc | 0. Étage | Finition ext - Crépis blanc
24 x Métal - Acier Bardage | 0. Étage | Métal - Acier Bardage
9 x Couche - Polyane | 0. Étage | Couche - Polyane
299 x Métal - Strcuture métal | 0. Étage | Métal - Strcuture métal
3 x Structural 0/20 | 0. Étage | Structural 0/20
3 x Struct. - B.A. coulé | 0. Étage | Struct. - B.A. coulé
Struct. - Hourdis Polystèrène | 0. Étage | Struct. - Hourdis Polystèrène
4043 x Métal - Acier Clôture | 0. Étage | Métal - Acier Clôture
30 x Plastic - Clôture | 0. Étage | Plastic - Clôture
27 x Cloison - Isolation | 0. Étage | Cloison - Isolation
4 x Finition int - Plaque de plâtre | 0. Étage | Finition int - Plaque de plâtre
Struct. - Chape | 0. Étage | Struct. - Chape
17 x Finition sol - Linoleum | 0. Étage | Finition sol - Linoleum
46 x Finition int - Plaque de plâtre cloison | 0. Étage | Finition int - Plaque de plâtre cloison
22 x Vitrage | 0. Étage | Vitrage
42 x Vide d'air | 0. Étage | Vide d'air
111 x Métal - Aluminium Menuiserie | 0. Étage | Métal - Aluminium Menuiserie
2 x Acier inoxydable | 0. Étage | Acier inoxydable
23 x Vitrage émaillé | 0. Étage | Vitrage émaillé
108 x Caoutchouc | 0. Étage | Caoutchouc
108 x Métal - Aluminium Menuiserie Intercalaire | 0. Étage | Métal - Aluminium Menuiserie Intercalaire
108 x Divers - VIDE +++ | 0. Étage | Divers - VIDE +++
16 x Plastique - PVC couleur | 0. Étage | Plastique - PVC couleur
Métal - Galvanisé JI 60-160-800 | 1. Étage | Métal - Galvanisé JI 60-160-800
Struct. - B.A. coulé | 1. Étage | Struct. - B.A. coulé
Struct. - Chape | 1. Étage | Struct. - Chape
Finition sol - Linoleum | 1. Étage | Finition sol - Linoleum
48 x Finition int - Plaque de plâtre cloison | 1. Étage | Finition int - Plaque de plâtre cloison
24 x Cloison - Isolation | 1. Étage | Cloison - Isolation
5 x Finition ext - Crépis blanc | 1. Étage | Finition ext - Crépis blanc
3 x Struct. - Brique creuse pour planelle | 1. Étage | Struct. - Brique creuse pour planelle
2 x Divers - Vide | 2. Étage | Divers - Vide
18 x Métal - Acier Bardage | 2. Étage | Métal - Acier Bardage
2 x Etanchéité - Pare vapeur | 2. Étage | Etanchéité - Pare vapeur
12 x Isolation - Laine de roche | 2. Étage | Isolation - Laine de roche
2 x Etanchéité - Acroche sur isolation | 2. Étage | Etanchéité - Acroche sur isolation
2 x Etanchéité - Elastomère Flam 180-25 | 2. Étage | Etanchéité - Elastomère Flam 180-25
2 x Etanchéité - finition Flam 180-AR | 2. Étage | Etanchéité - finition Flam 180-AR
326 x Métal - Strcuture métal | 2. Étage | Métal - Strcuture métal
8 x Couche - Polyane | 2. Étage | Couche - Polyane
Finition int - Plaque de plâtre CF + | 2. Étage | Finition int - Plaque de plâtre CF +
Isolation - Laine de roche dérouler | 2. Étage | Isolation - Laine de roche dérouler

# IfcBuildingElementProxy: 1177 x 1027 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-350
PANNEAU_MR_PRINCIPAL-334

# IfcBuildingElementProxy: 288 x 2387 x 32, PANNEAU_MR_PRINCIPAL-629
In: 0. Étage
Pset_ManufacturerOccurrence - SerialNumber: Sans
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Baie générique_v2017 (36)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
22 x FOF96/155 | 0. Étage
14 x Ff586/120 | 1. Étage

# IfcBuildingElementProxy: Banc d'angle 25 (4)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Bordures T Courbes (10)
In: -1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Bordures T Droites (25)
In: -1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: C01 - Cloison Placostil 98/62 - 2x1 Placoplatre® BA 18S - EI60 - 47dB - 3,55m 98 (41)
Name | In | Renovation Status
5 x MUR_EXT-004 | 0. Étage | New
5 x MUR_EXT-004 | 0. Étage | Existing
2 x MUR_EXT-005 | 0. Étage | New
2 x MUR_EXT-006 | 0. Étage | New
MUR_EXT-007 | 0. Étage | New
MUR_EXT-008 | 0. Étage | New
MUR_EXT-009 | 0. Étage | New
24 x MUR_EXT-003 | 1. Étage | New

# IfcBuildingElementProxy: C01 - Cloison intérieur: 72/48 73 (6)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: C01 - Joue faux plafonds 61 (4)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Cadre - Poteau 63 x 180 (40)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
CADRE_MR_POTEAU-539
CADRE_MR_POTEAU-761
CADRE_MR_POTEAU-506
CADRE_MR_POTEAU-538
CADRE_MR_POTEAU-537
CADRE_MR_POTEAU-156
CADRE_MR_POTEAU-157
CADRE_MR_POTEAU-159
CADRE_MR_POTEAU-160
CADRE_MR_POTEAU-162
CADRE_MR_POTEAU-163
CADRE_MR_POTEAU-503
CADRE_MR_POTEAU-502
CADRE_MR_POTEAU-425
CADRE_MR_POTEAU-427
CADRE_MR_POTEAU-501
CADRE_MR_POTEAU-536
CADRE_MR_POTEAU-423
CADRE_MR_POTEAU-475
CADRE_MR_POTEAU-476
CADRE_MR_POTEAU-477
CADRE_MR_POTEAU-478
CADRE_MR_POTEAU-760
CADRE_MR_POTEAU-759
CADRE_MR_POTEAU-758
CADRE_MR_POTEAU-757
CADRE_MR_POTEAU-756
CADRE_MR_POTEAU-755
CADRE_MR_POTEAU-754
CADRE_MR_POTEAU-741
CADRE_MR_POTEAU-742
CADRE_MR_POTEAU-743
CADRE_MR_POTEAU-744
CADRE_MR_POTEAU-745
CADRE_MR_POTEAU-746
CADRE_MR_POTEAU-747
CADRE_MR_POTEAU-748
CADRE_MR_POTEAU-765
CADRE_MR_POTEAU-766
CADRE_MR_POTEAU-764

# IfcBuildingElementProxy: Cadre - Traverse 63 x -46 (38)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
CADRE_MR_TRAVERSE-089
CADRE_MR_TRAVERSE-090
CADRE_MR_TRAVERSE-492
CADRE_MR_TRAVERSE-491
CADRE_MR_TRAVERSE-490
CADRE_MR_TRAVERSE-754
CADRE_MR_TRAVERSE-753
CADRE_MR_TRAVERSE-752
CADRE_MR_TRAVERSE-473
CADRE_MR_TRAVERSE-472
CADRE_MR_TRAVERSE-475
CADRE_MR_TRAVERSE-474
CADRE_MR_TRAVERSE-751
CADRE_MR_TRAVERSE-088
CADRE_MR_TRAVERSE-087
CADRE_MR_TRAVERSE-086
CADRE_MR_TRAVERSE-085
CADRE_MR_TRAVERSE-084
CADRE_MR_TRAVERSE-823
CADRE_MR_TRAVERSE-794
CADRE_MR_TRAVERSE-789
CADRE_MR_TRAVERSE-782
CADRE_MR_TRAVERSE-783
CADRE_MR_TRAVERSE-826
CADRE_MR_TRAVERSE-083
CADRE_MR_TRAVERSE-082
CADRE_MR_TRAVERSE-788
CADRE_MR_TRAVERSE-795
CADRE_MR_TRAVERSE-829
CADRE_MR_TRAVERSE-065
CADRE_MR_TRAVERSE-066
CADRE_MR_TRAVERSE-067
CADRE_MR_TRAVERSE-068
CADRE_MR_TRAVERSE-069
CADRE_MR_TRAVERSE-070
CADRE_MR_TRAVERSE-071
CADRE_MR_TRAVERSE-072
CADRE_MR_TRAVERSE-091

# IfcBuildingElementProxy: Cadre 57 x 180 (30)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
CADRE_MR-089
CADRE_MR-090
CADRE_MR-091
CADRE_MR-092
CADRE_MR-116
CADRE_MR-093
CADRE_MR-094
CADRE_MR-088
CADRE_MR-086
CADRE_MR-113
CADRE_MR-112
CADRE_MR-111
CADRE_MR-110
CADRE_MR-096
CADRE_MR-097
CADRE_MR-098
CADRE_MR-099
CADRE_MR-100
CADRE_MR-087
CADRE_MR-095
CADRE_MR-109
CADRE_MR-108
CADRE_MR-107
CADRE_MR-106
CADRE_MR-105
CADRE_MR-104
CADRE_MR-103
CADRE_MR-102
CADRE_MR-101
CADRE_MR-115

# IfcBuildingElementProxy: Capella CF111 (6)
In: 1. Étage
Pset_ManufacturerTypeInformation - Manufacturer: Kinnarps
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Casiers 25 (8)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Clavier (Apple) 25 (6)
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Coiffe métallique (1) 470 x 70 (8)
In: 2. Étage
Material: Métal - Aluminium Menuiserie
Name | Renovation Status
5 x PoBA-010 | Existing
PoBA-010 | New
PoBA-011 | New
PoBA-012 | New

# IfcBuildingElementProxy: Crawford OH1042P (5)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Douche rectangulaire 25 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Ecophon_Ceiling_Focus_E (25)
Pset_ManufacturerTypeInformation - Manufacturer: Ecophon
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
16 x Faux plafond déco | 0. Étage
9 x Faux plafond déco | 1. Étage

# IfcBuildingElementProxy: Elément bas 24, FU - 009
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Elément bas avec plusieurs tiroirs 24, TERREAL_DC16_Cathedrale
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Emaillé 1177 x 1027 x 32 (4)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
Panneau-Emaillé-031
Panneau-Emaillé-035
Panneau-Emaillé-036
Panneau-Emaillé-039

# IfcBuildingElementProxy: Emaillé 1177 x 555 x 32 (7)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-502
PANNEAU_MR_PRINCIPAL-503
PANNEAU_MR_PRINCIPAL-504
PANNEAU_MR_PRINCIPAL-505
PANNEAU_MR_PRINCIPAL-506
PANNEAU_MR_PRINCIPAL-507
PANNEAU_MR_PRINCIPAL-508

# IfcBuildingElementProxy: Emaillé 1177 x 577 x 32 (4)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
Panneau-Emaillé-008
Panneau-Emaillé-012
Panneau-Emaillé-020
Panneau-Emaillé-014

# IfcBuildingElementProxy: Emaillé 996 x 1027 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-511
PANNEAU_MR_PRINCIPAL-515

# IfcBuildingElementProxy: Emaillé 996 x 2387 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-509
PANNEAU_MR_PRINCIPAL-513

# IfcBuildingElementProxy: Emaillé 996 x 555 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-517
PANNEAU_MR_PRINCIPAL-516

# IfcBuildingElementProxy: Emaillé 996 x 577 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-510
PANNEAU_MR_PRINCIPAL-514

# IfcBuildingElementProxy: Env. - Terre remanié (9)
In: -1. Étage
Material: Env. - Terre remanié
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Fond 20 x 1568 x 2 (71)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
Panneau-Fond-163
Panneau-Fond-164
Panneau-Fond-165
Panneau-Fond-166
Panneau-Fond-167
Panneau-Fond-168
Panneau-Fond-169
Panneau-Fond-170
Panneau-Fond-171
Panneau-Fond-172
Panneau-Fond-173
Panneau-Fond-174
Panneau-Fond-175
Panneau-Fond-176
Panneau-Fond-177
Panneau-Fond-178
Panneau-Fond-179
Panneau-Fond-180
Panneau-Fond-181
Panneau-Fond-182
Panneau-Fond-183
Panneau-Fond-184
Panneau-Fond-185
Panneau-Fond-186
Panneau-Fond-187
Panneau-Fond-188
Panneau-Fond-189
Panneau-Fond-190
Panneau-Fond-191
Panneau-Fond-192
Panneau-Fond-193
Panneau-Fond-194
Panneau-Fond-195
Panneau-Fond-196
Panneau-Fond-197
Panneau-Fond-198
Panneau-Fond-199
Panneau-Fond-200
Panneau-Fond-201
Panneau-Fond-202
Panneau-Fond-203
Panneau-Fond-204
Panneau-Fond-205
Panneau-Fond-206
Panneau-Fond-207
Panneau-Fond-208
Panneau-Fond-209
Panneau-Fond-210
Panneau-Fond-211
Panneau-Fond-212
Panneau-Fond-213
Panneau-Fond-214
Panneau-Fond-215
Panneau-Fond-216
Panneau-Fond-217
Panneau-Fond-218
Panneau-Fond-219
Panneau-Fond-220
Panneau-Fond-221
Panneau-Fond-222
Panneau-Fond-223
Panneau-Fond-224
Panneau-Fond-225
Panneau-Fond-226
Panneau-Fond-227
Panneau-Fond-228
Panneau-Fond-229
Panneau-Fond-230
Panneau-Fond-231
Panneau-Fond-232
Panneau-Fond-233

# IfcBuildingElementProxy: Fond 20 x 1728 x 2 (213)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
3 x Panneau-Fond-163
3 x Panneau-Fond-164
3 x Panneau-Fond-165
3 x Panneau-Fond-166
3 x Panneau-Fond-167
3 x Panneau-Fond-168
3 x Panneau-Fond-169
3 x Panneau-Fond-170
3 x Panneau-Fond-171
3 x Panneau-Fond-172
3 x Panneau-Fond-173
3 x Panneau-Fond-174
3 x Panneau-Fond-175
3 x Panneau-Fond-176
3 x Panneau-Fond-177
3 x Panneau-Fond-178
3 x Panneau-Fond-179
3 x Panneau-Fond-180
3 x Panneau-Fond-181
3 x Panneau-Fond-182
3 x Panneau-Fond-183
3 x Panneau-Fond-184
3 x Panneau-Fond-185
3 x Panneau-Fond-186
3 x Panneau-Fond-187
3 x Panneau-Fond-188
3 x Panneau-Fond-189
3 x Panneau-Fond-190
3 x Panneau-Fond-191
3 x Panneau-Fond-192
3 x Panneau-Fond-193
3 x Panneau-Fond-194
3 x Panneau-Fond-195
3 x Panneau-Fond-196
3 x Panneau-Fond-197
3 x Panneau-Fond-198
3 x Panneau-Fond-199
3 x Panneau-Fond-200
3 x Panneau-Fond-201
3 x Panneau-Fond-202
3 x Panneau-Fond-203
3 x Panneau-Fond-204
3 x Panneau-Fond-205
3 x Panneau-Fond-206
3 x Panneau-Fond-207
3 x Panneau-Fond-208
3 x Panneau-Fond-209
3 x Panneau-Fond-210
3 x Panneau-Fond-211
3 x Panneau-Fond-212
3 x Panneau-Fond-213
3 x Panneau-Fond-214
3 x Panneau-Fond-215
3 x Panneau-Fond-216
3 x Panneau-Fond-217
3 x Panneau-Fond-218
3 x Panneau-Fond-219
3 x Panneau-Fond-220
3 x Panneau-Fond-221
3 x Panneau-Fond-222
3 x Panneau-Fond-223
3 x Panneau-Fond-224
3 x Panneau-Fond-225
3 x Panneau-Fond-226
3 x Panneau-Fond-227
3 x Panneau-Fond-228
3 x Panneau-Fond-229
3 x Panneau-Fond-230
3 x Panneau-Fond-231
3 x Panneau-Fond-232
3 x Panneau-Fond-233

# IfcBuildingElementProxy: Fond 20 x 2428 x 2 (51)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
Panneau-Fond-143
Panneau-Fond-144
Panneau-Fond-145
Panneau-Fond-146
Panneau-Fond-147
Panneau-Fond-148
Panneau-Fond-149
Panneau-Fond-150
Panneau-Fond-151
Panneau-Fond-152
Panneau-Fond-153
Panneau-Fond-154
Panneau-Fond-155
Panneau-Fond-156
Panneau-Fond-157
Panneau-Fond-158
Panneau-Fond-159
Panneau-Fond-160
Panneau-Fond-161
Panneau-Fond-162
Panneau-Fond-163
Panneau-Fond-164
Panneau-Fond-165
Panneau-Fond-166
Panneau-Fond-167
Panneau-Fond-168
Panneau-Fond-169
Panneau-Fond-170
Panneau-Fond-171
Panneau-Fond-172
Panneau-Fond-173
Panneau-Fond-174
Panneau-Fond-175
Panneau-Fond-176
Panneau-Fond-177
Panneau-Fond-178
Panneau-Fond-179
Panneau-Fond-180
Panneau-Fond-181
Panneau-Fond-182
Panneau-Fond-183
Panneau-Fond-184
Panneau-Fond-185
Panneau-Fond-186
Panneau-Fond-187
Panneau-Fond-188
Panneau-Fond-189
Panneau-Fond-190
Panneau-Fond-191
Panneau-Fond-192
Panneau-Fond-193

# IfcBuildingElementProxy: Fond 20 x 2588 x 2 (521)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
2 x Panneau-Fond-066
2 x Panneau-Fond-067
2 x Panneau-Fond-068
2 x Panneau-Fond-069
2 x Panneau-Fond-070
2 x Panneau-Fond-071
2 x Panneau-Fond-072
2 x Panneau-Fond-073
2 x Panneau-Fond-074
2 x Panneau-Fond-075
2 x Panneau-Fond-076
2 x Panneau-Fond-077
2 x Panneau-Fond-078
2 x Panneau-Fond-079
2 x Panneau-Fond-080
2 x Panneau-Fond-081
2 x Panneau-Fond-082
2 x Panneau-Fond-083
2 x Panneau-Fond-084
2 x Panneau-Fond-085
2 x Panneau-Fond-086
2 x Panneau-Fond-087
2 x Panneau-Fond-088
2 x Panneau-Fond-089
2 x Panneau-Fond-090
2 x Panneau-Fond-091
4 x Panneau-Fond-092
4 x Panneau-Fond-093
4 x Panneau-Fond-094
4 x Panneau-Fond-095
4 x Panneau-Fond-096
4 x Panneau-Fond-097
4 x Panneau-Fond-098
4 x Panneau-Fond-099
4 x Panneau-Fond-100
4 x Panneau-Fond-101
4 x Panneau-Fond-102
4 x Panneau-Fond-103
4 x Panneau-Fond-104
4 x Panneau-Fond-105
4 x Panneau-Fond-106
4 x Panneau-Fond-107
4 x Panneau-Fond-108
4 x Panneau-Fond-109
4 x Panneau-Fond-110
4 x Panneau-Fond-111
4 x Panneau-Fond-112
4 x Panneau-Fond-113
4 x Panneau-Fond-114
4 x Panneau-Fond-115
4 x Panneau-Fond-116
4 x Panneau-Fond-117
4 x Panneau-Fond-118
4 x Panneau-Fond-119
4 x Panneau-Fond-120
4 x Panneau-Fond-121
4 x Panneau-Fond-122
4 x Panneau-Fond-123
4 x Panneau-Fond-124
4 x Panneau-Fond-125
4 x Panneau-Fond-126
4 x Panneau-Fond-127
4 x Panneau-Fond-128
4 x Panneau-Fond-129
4 x Panneau-Fond-130
2 x Panneau-Fond-131
2 x Panneau-Fond-132
2 x Panneau-Fond-133
2 x Panneau-Fond-134
2 x Panneau-Fond-135
2 x Panneau-Fond-136
2 x Panneau-Fond-137
2 x Panneau-Fond-138
2 x Panneau-Fond-139
2 x Panneau-Fond-140
2 x Panneau-Fond-141
2 x Panneau-Fond-142
3 x Panneau-Fond-143
3 x Panneau-Fond-144
3 x Panneau-Fond-145
3 x Panneau-Fond-146
3 x Panneau-Fond-147
3 x Panneau-Fond-148
3 x Panneau-Fond-149
3 x Panneau-Fond-150
3 x Panneau-Fond-151
3 x Panneau-Fond-152
3 x Panneau-Fond-153
3 x Panneau-Fond-154
3 x Panneau-Fond-155
3 x Panneau-Fond-156
3 x Panneau-Fond-157
3 x Panneau-Fond-158
3 x Panneau-Fond-159
3 x Panneau-Fond-160
3 x Panneau-Fond-161
3 x Panneau-Fond-162
3 x Panneau-Fond-163
3 x Panneau-Fond-164
3 x Panneau-Fond-165
3 x Panneau-Fond-166
3 x Panneau-Fond-167
3 x Panneau-Fond-168
3 x Panneau-Fond-169
3 x Panneau-Fond-170
3 x Panneau-Fond-171
3 x Panneau-Fond-172
3 x Panneau-Fond-173
3 x Panneau-Fond-174
3 x Panneau-Fond-175
3 x Panneau-Fond-176
3 x Panneau-Fond-177
3 x Panneau-Fond-178
3 x Panneau-Fond-179
3 x Panneau-Fond-180
3 x Panneau-Fond-181
3 x Panneau-Fond-182
3 x Panneau-Fond-183
3 x Panneau-Fond-184
3 x Panneau-Fond-185
3 x Panneau-Fond-186
3 x Panneau-Fond-187
3 x Panneau-Fond-188
3 x Panneau-Fond-189
3 x Panneau-Fond-190
3 x Panneau-Fond-191
3 x Panneau-Fond-192
3 x Panneau-Fond-193
2 x Panneau-Fond-194
2 x Panneau-Fond-195
2 x Panneau-Fond-196
2 x Panneau-Fond-197
2 x Panneau-Fond-198
2 x Panneau-Fond-199
2 x Panneau-Fond-200
2 x Panneau-Fond-201
2 x Panneau-Fond-202
2 x Panneau-Fond-203
2 x Panneau-Fond-204
2 x Panneau-Fond-205
2 x Panneau-Fond-206
2 x Panneau-Fond-207
2 x Panneau-Fond-208
2 x Panneau-Fond-209
2 x Panneau-Fond-210
2 x Panneau-Fond-211
2 x Panneau-Fond-212
2 x Panneau-Fond-213
2 x Panneau-Fond-214
2 x Panneau-Fond-215
2 x Panneau-Fond-216
2 x Panneau-Fond-217
2 x Panneau-Fond-218
2 x Panneau-Fond-219
2 x Panneau-Fond-220
2 x Panneau-Fond-221
2 x Panneau-Fond-222
2 x Panneau-Fond-223
2 x Panneau-Fond-224
2 x Panneau-Fond-225
2 x Panneau-Fond-226
2 x Panneau-Fond-227
2 x Panneau-Fond-228
2 x Panneau-Fond-229
2 x Panneau-Fond-230
2 x Panneau-Fond-231
2 x Panneau-Fond-232
2 x Panneau-Fond-233
2 x Panneau-Fond-234
2 x Panneau-Fond-235
2 x Panneau-Fond-236
2 x Panneau-Fond-237
2 x Panneau-Fond-238
2 x Panneau-Fond-239
2 x Panneau-Fond-240
2 x Panneau-Fond-241
2 x Panneau-Fond-242
2 x Panneau-Fond-243
2 x Panneau-Fond-244
2 x Panneau-Fond-245
2 x Panneau-Fond-246
2 x Panneau-Fond-247
2 x Panneau-Fond-248
2 x Panneau-Fond-249
2 x Panneau-Fond-250
2 x Panneau-Fond-251
2 x Panneau-Fond-252
2 x Panneau-Fond-253
2 x Panneau-Fond-254
2 x Panneau-Fond-255
2 x Panneau-Fond-256
2 x Panneau-Fond-257
2 x Panneau-Fond-258
2 x Panneau-Fond-259
2 x Panneau-Fond-260
2 x Panneau-Fond-261

# IfcBuildingElementProxy: Fond 20 x 2888 x 2 (65)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Fond 20 x 900 x 2 (252)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
5 x Panneau-Fond-043
5 x Panneau-Fond-044
5 x Panneau-Fond-045
5 x Panneau-Fond-046
5 x Panneau-Fond-047
5 x Panneau-Fond-048
5 x Panneau-Fond-049
5 x Panneau-Fond-050
5 x Panneau-Fond-051
5 x Panneau-Fond-052
5 x Panneau-Fond-053
5 x Panneau-Fond-054
5 x Panneau-Fond-055
5 x Panneau-Fond-056
5 x Panneau-Fond-057
5 x Panneau-Fond-058
5 x Panneau-Fond-059
5 x Panneau-Fond-060
5 x Panneau-Fond-061
5 x Panneau-Fond-062
5 x Panneau-Fond-063
5 x Panneau-Fond-064
5 x Panneau-Fond-065
5 x Panneau-Fond-066
5 x Panneau-Fond-067
5 x Panneau-Fond-068
5 x Panneau-Fond-069
5 x Panneau-Fond-070
5 x Panneau-Fond-071
5 x Panneau-Fond-072
5 x Panneau-Fond-073
5 x Panneau-Fond-074
5 x Panneau-Fond-075
5 x Panneau-Fond-076
5 x Panneau-Fond-077
5 x Panneau-Fond-078
5 x Panneau-Fond-079
5 x Panneau-Fond-080
5 x Panneau-Fond-081
5 x Panneau-Fond-082
5 x Panneau-Fond-083
5 x Panneau-Fond-084
Panneau-Fond-085
Panneau-Fond-086
Panneau-Fond-087
Panneau-Fond-088
Panneau-Fond-089
Panneau-Fond-090
Panneau-Fond-091
Panneau-Fond-092
Panneau-Fond-093
Panneau-Fond-094
Panneau-Fond-095
Panneau-Fond-096
Panneau-Fond-097
Panneau-Fond-098
Panneau-Fond-099
Panneau-Fond-100
Panneau-Fond-101
Panneau-Fond-102
Panneau-Fond-103
Panneau-Fond-104
Panneau-Fond-105
Panneau-Fond-106
Panneau-Fond-107
Panneau-Fond-108
Panneau-Fond-109
Panneau-Fond-110
Panneau-Fond-111
Panneau-Fond-112
Panneau-Fond-113
Panneau-Fond-114
Panneau-Fond-115
Panneau-Fond-116
Panneau-Fond-117
Panneau-Fond-118
Panneau-Fond-119
Panneau-Fond-120
Panneau-Fond-121
Panneau-Fond-122
Panneau-Fond-123
Panneau-Fond-124
Panneau-Fond-125
Panneau-Fond-126

# IfcBuildingElementProxy: Frigo_OD
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Icopal System Svita Sky Vent (8)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: IfcBuildingElementProxy (33)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Material
VOLEE-017 | Béton armé (Coulé)
C-MARCHE-110 | Métal - Fer
C-MARCHE-111 | Métal - Fer
C-MARCHE-112 | Métal - Fer
C-MARCHE-113 | Métal - Fer
C-MARCHE-114 | Métal - Fer
C-MARCHE-115 | Métal - Fer
C-MARCHE-116 | Métal - Fer
C-MARCHE-117 | Métal - Fer
C-MARCHE-118 | Métal - Fer
C-MARCHE-119 | Métal - Fer
C-MARCHE-120 | Métal - Fer
C-MARCHE-121 | Métal - Fer
C-MARCHE-122 | Métal - Fer
C-MARCHE-123 | Métal - Fer
C-MARCHE-124 | Métal - Fer
C-MARCHE-125 | Métal - Fer
MARCHE-113
MARCHE-114
MARCHE-115
MARCHE-116
MARCHE-117
MARCHE-118
MARCHE-119
MARCHE-120
MARCHE-121
MARCHE-122
MARCHE-123
MARCHE-124
MARCHE-125
MARCHE-126
MARCHE-127
MARCHE-128

# IfcBuildingElementProxy: KinCh376 (34)
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: KinTa130AP (2)
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Lavabo 25 (5)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
4 x WC | 0. Étage
WC | 1. Étage

# IfcBuildingElementProxy: M01 - S: Bac acier double peaux 151 (8)
In: 0. Étage
Name | Renovation Status
3 x MUR_EXT-012 | Existing
3 x MUR_EXT-012 | New
MUR_EXT-014 | New
MUR_EXT-013 | New

# IfcBuildingElementProxy: M01 - S: Bac acier simple peaux 101 (8)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: M01 - S: Brique(P): 20 - E: Enduit : 2 - I: Doublage : 12 360 (3)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: M01 - S: Brique: 20 - E: Enduit - I. Enduit 240 (3)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
MUR_EXT-002 | 0. Étage
2 x MUR_EXT-002 | 1. Étage

# IfcBuildingElementProxy: M01 - S: Brique: 20 - I : Enduit 220, MUR_EXT-003
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Modèle d'arbre détaillé 25 (15)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
033
032
031
034
030
028
029
020
021
022
023
024
025
026
027

# IfcBuildingElementProxy: Métal - Aluminium Habillage 2 (8)
In: 0. Étage
Material: Métal - Aluminium Habillage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
4 x MUR_EXT-012
4 x MUR_EXT-013

# IfcBuildingElementProxy: Métal - Aluminium Habillage 316 (4)
In: 0. Étage
Material: Métal - Aluminium Habillage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Métal - Fer 10 (4)
In: 0. Étage
Material: Métal - Fer
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Métal - Fer 150 (14)
In: 1. Étage
Material: Métal - Fer
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Métal - Fer 290 (2)
In: 0. Étage
Material: Métal - Fer
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Oberon Table Angle 2 (6)
In: 1. Étage
Pset_ManufacturerTypeInformation - Manufacturer: Kinnarps
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Oberon Table Rect 1 (8)
In: 1. Étage
Pset_ManufacturerTypeInformation - Manufacturer: Kinnarps
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: P01 - Plancher BA 15 + 10 455 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: P01 - Plancher BA 15 + 10 isolé 475, Chape_sol
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: P01 - Plancher Collaborant 120, Chape_sol
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: P02- Faux plafond 2xB15 + iso soufflet 45 465, Plafond
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Panneau principal 11 x 1568 x 25, PANNEAU_MR_PRINCIPAL-141
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 11 x 1728 x 25 (3)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 11 x 2428 x 25, PANNEAU_MR_PRINCIPAL-050
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 11 x 2588 x 25 (3)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
2 x PANNEAU_MR_PRINCIPAL-123
PANNEAU_MR_PRINCIPAL-050

# IfcBuildingElementProxy: Panneau principal 1177 x 1027 x 32 (8)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
Panneau-Emaillé-032
Panneau-Emaillé-033
Panneau-Emaillé-034
PANNEAU_MR_PRINCIPAL-293
PANNEAU_MR_PRINCIPAL-296
PANNEAU_MR_PRINCIPAL-291
PANNEAU_MR_PRINCIPAL-292
PANNEAU_MR_PRINCIPAL-327

# IfcBuildingElementProxy: Panneau principal 1177 x 2387 x 32 (4)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-322
PANNEAU_MR_PRINCIPAL-347
PANNEAU_MR_PRINCIPAL-333
PANNEAU_MR_PRINCIPAL-629

# IfcBuildingElementProxy: Panneau principal 1177 x 577 x 32 (3)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
Panneau-Emaillé-011
Panneau-Emaillé-009
Panneau-Emaillé-010

# IfcBuildingElementProxy: Panneau principal 19 x 1568 x 25, PANNEAU_MR_PRINCIPAL-070
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 19 x 1728 x 25 (3)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 21 x 2588 x 25 (2)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 25 x 1568 x 25 (70)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-071
PANNEAU_MR_PRINCIPAL-072
PANNEAU_MR_PRINCIPAL-073
PANNEAU_MR_PRINCIPAL-074
PANNEAU_MR_PRINCIPAL-075
PANNEAU_MR_PRINCIPAL-076
PANNEAU_MR_PRINCIPAL-077
PANNEAU_MR_PRINCIPAL-078
PANNEAU_MR_PRINCIPAL-079
PANNEAU_MR_PRINCIPAL-080
PANNEAU_MR_PRINCIPAL-081
PANNEAU_MR_PRINCIPAL-082
PANNEAU_MR_PRINCIPAL-083
PANNEAU_MR_PRINCIPAL-084
PANNEAU_MR_PRINCIPAL-085
PANNEAU_MR_PRINCIPAL-086
PANNEAU_MR_PRINCIPAL-087
PANNEAU_MR_PRINCIPAL-088
PANNEAU_MR_PRINCIPAL-089
PANNEAU_MR_PRINCIPAL-090
PANNEAU_MR_PRINCIPAL-091
PANNEAU_MR_PRINCIPAL-092
PANNEAU_MR_PRINCIPAL-093
PANNEAU_MR_PRINCIPAL-094
PANNEAU_MR_PRINCIPAL-095
PANNEAU_MR_PRINCIPAL-096
PANNEAU_MR_PRINCIPAL-097
PANNEAU_MR_PRINCIPAL-098
PANNEAU_MR_PRINCIPAL-099
PANNEAU_MR_PRINCIPAL-100
PANNEAU_MR_PRINCIPAL-101
PANNEAU_MR_PRINCIPAL-102
PANNEAU_MR_PRINCIPAL-103
PANNEAU_MR_PRINCIPAL-104
PANNEAU_MR_PRINCIPAL-105
PANNEAU_MR_PRINCIPAL-106
PANNEAU_MR_PRINCIPAL-107
PANNEAU_MR_PRINCIPAL-108
PANNEAU_MR_PRINCIPAL-109
PANNEAU_MR_PRINCIPAL-110
PANNEAU_MR_PRINCIPAL-111
PANNEAU_MR_PRINCIPAL-112
PANNEAU_MR_PRINCIPAL-113
PANNEAU_MR_PRINCIPAL-114
PANNEAU_MR_PRINCIPAL-115
PANNEAU_MR_PRINCIPAL-116
PANNEAU_MR_PRINCIPAL-117
PANNEAU_MR_PRINCIPAL-118
PANNEAU_MR_PRINCIPAL-119
PANNEAU_MR_PRINCIPAL-120
PANNEAU_MR_PRINCIPAL-121
PANNEAU_MR_PRINCIPAL-122
PANNEAU_MR_PRINCIPAL-123
PANNEAU_MR_PRINCIPAL-124
PANNEAU_MR_PRINCIPAL-125
PANNEAU_MR_PRINCIPAL-126
PANNEAU_MR_PRINCIPAL-127
PANNEAU_MR_PRINCIPAL-128
PANNEAU_MR_PRINCIPAL-129
PANNEAU_MR_PRINCIPAL-130
PANNEAU_MR_PRINCIPAL-131
PANNEAU_MR_PRINCIPAL-132
PANNEAU_MR_PRINCIPAL-133
PANNEAU_MR_PRINCIPAL-134
PANNEAU_MR_PRINCIPAL-135
PANNEAU_MR_PRINCIPAL-136
PANNEAU_MR_PRINCIPAL-137
PANNEAU_MR_PRINCIPAL-138
PANNEAU_MR_PRINCIPAL-139
PANNEAU_MR_PRINCIPAL-140

# IfcBuildingElementProxy: Panneau principal 25 x 1728 x 25 (210)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
3 x PANNEAU_MR_PRINCIPAL-071
3 x PANNEAU_MR_PRINCIPAL-072
3 x PANNEAU_MR_PRINCIPAL-073
3 x PANNEAU_MR_PRINCIPAL-074
3 x PANNEAU_MR_PRINCIPAL-075
3 x PANNEAU_MR_PRINCIPAL-076
3 x PANNEAU_MR_PRINCIPAL-077
3 x PANNEAU_MR_PRINCIPAL-078
3 x PANNEAU_MR_PRINCIPAL-079
3 x PANNEAU_MR_PRINCIPAL-080
3 x PANNEAU_MR_PRINCIPAL-081
3 x PANNEAU_MR_PRINCIPAL-082
3 x PANNEAU_MR_PRINCIPAL-083
3 x PANNEAU_MR_PRINCIPAL-084
3 x PANNEAU_MR_PRINCIPAL-085
3 x PANNEAU_MR_PRINCIPAL-086
3 x PANNEAU_MR_PRINCIPAL-087
3 x PANNEAU_MR_PRINCIPAL-088
3 x PANNEAU_MR_PRINCIPAL-089
3 x PANNEAU_MR_PRINCIPAL-090
3 x PANNEAU_MR_PRINCIPAL-091
3 x PANNEAU_MR_PRINCIPAL-092
3 x PANNEAU_MR_PRINCIPAL-093
3 x PANNEAU_MR_PRINCIPAL-094
3 x PANNEAU_MR_PRINCIPAL-095
3 x PANNEAU_MR_PRINCIPAL-096
3 x PANNEAU_MR_PRINCIPAL-097
3 x PANNEAU_MR_PRINCIPAL-098
3 x PANNEAU_MR_PRINCIPAL-099
3 x PANNEAU_MR_PRINCIPAL-100
3 x PANNEAU_MR_PRINCIPAL-101
3 x PANNEAU_MR_PRINCIPAL-102
3 x PANNEAU_MR_PRINCIPAL-103
3 x PANNEAU_MR_PRINCIPAL-104
3 x PANNEAU_MR_PRINCIPAL-105
3 x PANNEAU_MR_PRINCIPAL-106
3 x PANNEAU_MR_PRINCIPAL-107
3 x PANNEAU_MR_PRINCIPAL-108
3 x PANNEAU_MR_PRINCIPAL-109
3 x PANNEAU_MR_PRINCIPAL-110
3 x PANNEAU_MR_PRINCIPAL-111
3 x PANNEAU_MR_PRINCIPAL-112
3 x PANNEAU_MR_PRINCIPAL-113
3 x PANNEAU_MR_PRINCIPAL-114
3 x PANNEAU_MR_PRINCIPAL-115
3 x PANNEAU_MR_PRINCIPAL-116
3 x PANNEAU_MR_PRINCIPAL-117
3 x PANNEAU_MR_PRINCIPAL-118
3 x PANNEAU_MR_PRINCIPAL-119
3 x PANNEAU_MR_PRINCIPAL-120
3 x PANNEAU_MR_PRINCIPAL-121
3 x PANNEAU_MR_PRINCIPAL-122
3 x PANNEAU_MR_PRINCIPAL-123
3 x PANNEAU_MR_PRINCIPAL-124
3 x PANNEAU_MR_PRINCIPAL-125
3 x PANNEAU_MR_PRINCIPAL-126
3 x PANNEAU_MR_PRINCIPAL-127
3 x PANNEAU_MR_PRINCIPAL-128
3 x PANNEAU_MR_PRINCIPAL-129
3 x PANNEAU_MR_PRINCIPAL-130
3 x PANNEAU_MR_PRINCIPAL-131
3 x PANNEAU_MR_PRINCIPAL-132
3 x PANNEAU_MR_PRINCIPAL-133
3 x PANNEAU_MR_PRINCIPAL-134
3 x PANNEAU_MR_PRINCIPAL-135
3 x PANNEAU_MR_PRINCIPAL-136
3 x PANNEAU_MR_PRINCIPAL-137
3 x PANNEAU_MR_PRINCIPAL-138
3 x PANNEAU_MR_PRINCIPAL-139
3 x PANNEAU_MR_PRINCIPAL-140

# IfcBuildingElementProxy: Panneau principal 25 x 2428 x 25 (51)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-051
PANNEAU_MR_PRINCIPAL-052
PANNEAU_MR_PRINCIPAL-053
PANNEAU_MR_PRINCIPAL-054
PANNEAU_MR_PRINCIPAL-055
PANNEAU_MR_PRINCIPAL-056
PANNEAU_MR_PRINCIPAL-057
PANNEAU_MR_PRINCIPAL-058
PANNEAU_MR_PRINCIPAL-059
PANNEAU_MR_PRINCIPAL-060
PANNEAU_MR_PRINCIPAL-061
PANNEAU_MR_PRINCIPAL-062
PANNEAU_MR_PRINCIPAL-063
PANNEAU_MR_PRINCIPAL-064
PANNEAU_MR_PRINCIPAL-065
PANNEAU_MR_PRINCIPAL-066
PANNEAU_MR_PRINCIPAL-067
PANNEAU_MR_PRINCIPAL-068
PANNEAU_MR_PRINCIPAL-069
PANNEAU_MR_PRINCIPAL-070
PANNEAU_MR_PRINCIPAL-071
PANNEAU_MR_PRINCIPAL-072
PANNEAU_MR_PRINCIPAL-073
PANNEAU_MR_PRINCIPAL-074
PANNEAU_MR_PRINCIPAL-075
PANNEAU_MR_PRINCIPAL-076
PANNEAU_MR_PRINCIPAL-077
PANNEAU_MR_PRINCIPAL-078
PANNEAU_MR_PRINCIPAL-079
PANNEAU_MR_PRINCIPAL-080
PANNEAU_MR_PRINCIPAL-081
PANNEAU_MR_PRINCIPAL-082
PANNEAU_MR_PRINCIPAL-083
PANNEAU_MR_PRINCIPAL-084
PANNEAU_MR_PRINCIPAL-085
PANNEAU_MR_PRINCIPAL-086
PANNEAU_MR_PRINCIPAL-087
PANNEAU_MR_PRINCIPAL-088
PANNEAU_MR_PRINCIPAL-089
PANNEAU_MR_PRINCIPAL-090
PANNEAU_MR_PRINCIPAL-091
PANNEAU_MR_PRINCIPAL-092
PANNEAU_MR_PRINCIPAL-093
PANNEAU_MR_PRINCIPAL-094
PANNEAU_MR_PRINCIPAL-095
PANNEAU_MR_PRINCIPAL-096
PANNEAU_MR_PRINCIPAL-097
PANNEAU_MR_PRINCIPAL-098
PANNEAU_MR_PRINCIPAL-099
PANNEAU_MR_PRINCIPAL-100
PANNEAU_MR_PRINCIPAL-101

# IfcBuildingElementProxy: Panneau principal 25 x 2588 x 25 (521)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
2 x PANNEAU_MR_PRINCIPAL-234
2 x PANNEAU_MR_PRINCIPAL-235
2 x PANNEAU_MR_PRINCIPAL-236
2 x PANNEAU_MR_PRINCIPAL-237
2 x PANNEAU_MR_PRINCIPAL-238
2 x PANNEAU_MR_PRINCIPAL-239
2 x PANNEAU_MR_PRINCIPAL-240
2 x PANNEAU_MR_PRINCIPAL-241
2 x PANNEAU_MR_PRINCIPAL-242
2 x PANNEAU_MR_PRINCIPAL-243
2 x PANNEAU_MR_PRINCIPAL-244
2 x PANNEAU_MR_PRINCIPAL-245
2 x PANNEAU_MR_PRINCIPAL-246
2 x PANNEAU_MR_PRINCIPAL-247
2 x PANNEAU_MR_PRINCIPAL-248
2 x PANNEAU_MR_PRINCIPAL-249
2 x PANNEAU_MR_PRINCIPAL-250
2 x PANNEAU_MR_PRINCIPAL-251
2 x PANNEAU_MR_PRINCIPAL-252
2 x PANNEAU_MR_PRINCIPAL-253
2 x PANNEAU_MR_PRINCIPAL-254
2 x PANNEAU_MR_PRINCIPAL-255
2 x PANNEAU_MR_PRINCIPAL-256
2 x PANNEAU_MR_PRINCIPAL-257
2 x PANNEAU_MR_PRINCIPAL-258
2 x PANNEAU_MR_PRINCIPAL-259
2 x PANNEAU_MR_PRINCIPAL-260
2 x PANNEAU_MR_PRINCIPAL-261
2 x PANNEAU_MR_PRINCIPAL-262
2 x PANNEAU_MR_PRINCIPAL-263
2 x PANNEAU_MR_PRINCIPAL-264
2 x PANNEAU_MR_PRINCIPAL-265
2 x PANNEAU_MR_PRINCIPAL-266
2 x PANNEAU_MR_PRINCIPAL-267
2 x PANNEAU_MR_PRINCIPAL-268
2 x PANNEAU_MR_PRINCIPAL-269
2 x PANNEAU_MR_PRINCIPAL-270
2 x PANNEAU_MR_PRINCIPAL-271
2 x PANNEAU_MR_PRINCIPAL-272
2 x PANNEAU_MR_PRINCIPAL-273
2 x PANNEAU_MR_PRINCIPAL-274
2 x PANNEAU_MR_PRINCIPAL-275
2 x PANNEAU_MR_PRINCIPAL-276
2 x PANNEAU_MR_PRINCIPAL-277
2 x PANNEAU_MR_PRINCIPAL-278
2 x PANNEAU_MR_PRINCIPAL-279
2 x PANNEAU_MR_PRINCIPAL-280
2 x PANNEAU_MR_PRINCIPAL-281
2 x PANNEAU_MR_PRINCIPAL-282
2 x PANNEAU_MR_PRINCIPAL-283
2 x PANNEAU_MR_PRINCIPAL-284
2 x PANNEAU_MR_PRINCIPAL-285
2 x PANNEAU_MR_PRINCIPAL-286
2 x PANNEAU_MR_PRINCIPAL-287
2 x PANNEAU_MR_PRINCIPAL-288
2 x PANNEAU_MR_PRINCIPAL-289
2 x PANNEAU_MR_PRINCIPAL-290
2 x PANNEAU_MR_PRINCIPAL-291
2 x PANNEAU_MR_PRINCIPAL-292
2 x PANNEAU_MR_PRINCIPAL-293
2 x PANNEAU_MR_PRINCIPAL-294
2 x PANNEAU_MR_PRINCIPAL-295
2 x PANNEAU_MR_PRINCIPAL-296
2 x PANNEAU_MR_PRINCIPAL-297
2 x PANNEAU_MR_PRINCIPAL-298
2 x PANNEAU_MR_PRINCIPAL-998
2 x PANNEAU_MR_PRINCIPAL-999
2 x PANNEAU_MR_PRINCIPAL-000
2 x PANNEAU_MR_PRINCIPAL-002
2 x PANNEAU_MR_PRINCIPAL-003
2 x PANNEAU_MR_PRINCIPAL-004
2 x PANNEAU_MR_PRINCIPAL-005
2 x PANNEAU_MR_PRINCIPAL-006
2 x PANNEAU_MR_PRINCIPAL-007
2 x PANNEAU_MR_PRINCIPAL-008
2 x PANNEAU_MR_PRINCIPAL-009
2 x PANNEAU_MR_PRINCIPAL-010
2 x PANNEAU_MR_PRINCIPAL-011
2 x PANNEAU_MR_PRINCIPAL-012
2 x PANNEAU_MR_PRINCIPAL-013
2 x PANNEAU_MR_PRINCIPAL-014
2 x PANNEAU_MR_PRINCIPAL-015
2 x PANNEAU_MR_PRINCIPAL-016
2 x PANNEAU_MR_PRINCIPAL-017
2 x PANNEAU_MR_PRINCIPAL-018
2 x PANNEAU_MR_PRINCIPAL-019
2 x PANNEAU_MR_PRINCIPAL-020
2 x PANNEAU_MR_PRINCIPAL-021
2 x PANNEAU_MR_PRINCIPAL-022
2 x PANNEAU_MR_PRINCIPAL-023
2 x PANNEAU_MR_PRINCIPAL-024
2 x PANNEAU_MR_PRINCIPAL-025
2 x PANNEAU_MR_PRINCIPAL-026
2 x PANNEAU_MR_PRINCIPAL-027
2 x PANNEAU_MR_PRINCIPAL-028
2 x PANNEAU_MR_PRINCIPAL-029
2 x PANNEAU_MR_PRINCIPAL-030
2 x PANNEAU_MR_PRINCIPAL-031
2 x PANNEAU_MR_PRINCIPAL-032
2 x PANNEAU_MR_PRINCIPAL-033
2 x PANNEAU_MR_PRINCIPAL-034
2 x PANNEAU_MR_PRINCIPAL-035
2 x PANNEAU_MR_PRINCIPAL-036
2 x PANNEAU_MR_PRINCIPAL-037
2 x PANNEAU_MR_PRINCIPAL-038
2 x PANNEAU_MR_PRINCIPAL-039
2 x PANNEAU_MR_PRINCIPAL-040
2 x PANNEAU_MR_PRINCIPAL-041
2 x PANNEAU_MR_PRINCIPAL-042
2 x PANNEAU_MR_PRINCIPAL-043
2 x PANNEAU_MR_PRINCIPAL-044
2 x PANNEAU_MR_PRINCIPAL-045
2 x PANNEAU_MR_PRINCIPAL-046
2 x PANNEAU_MR_PRINCIPAL-047
2 x PANNEAU_MR_PRINCIPAL-048
2 x PANNEAU_MR_PRINCIPAL-049
2 x PANNEAU_MR_PRINCIPAL-050
3 x PANNEAU_MR_PRINCIPAL-051
3 x PANNEAU_MR_PRINCIPAL-052
3 x PANNEAU_MR_PRINCIPAL-053
3 x PANNEAU_MR_PRINCIPAL-054
3 x PANNEAU_MR_PRINCIPAL-055
3 x PANNEAU_MR_PRINCIPAL-056
3 x PANNEAU_MR_PRINCIPAL-057
3 x PANNEAU_MR_PRINCIPAL-058
3 x PANNEAU_MR_PRINCIPAL-059
3 x PANNEAU_MR_PRINCIPAL-060
3 x PANNEAU_MR_PRINCIPAL-061
3 x PANNEAU_MR_PRINCIPAL-062
3 x PANNEAU_MR_PRINCIPAL-063
3 x PANNEAU_MR_PRINCIPAL-064
3 x PANNEAU_MR_PRINCIPAL-065
3 x PANNEAU_MR_PRINCIPAL-066
3 x PANNEAU_MR_PRINCIPAL-067
3 x PANNEAU_MR_PRINCIPAL-068
3 x PANNEAU_MR_PRINCIPAL-069
3 x PANNEAU_MR_PRINCIPAL-070
3 x PANNEAU_MR_PRINCIPAL-071
3 x PANNEAU_MR_PRINCIPAL-072
3 x PANNEAU_MR_PRINCIPAL-073
3 x PANNEAU_MR_PRINCIPAL-074
3 x PANNEAU_MR_PRINCIPAL-075
3 x PANNEAU_MR_PRINCIPAL-076
3 x PANNEAU_MR_PRINCIPAL-077
3 x PANNEAU_MR_PRINCIPAL-078
3 x PANNEAU_MR_PRINCIPAL-079
3 x PANNEAU_MR_PRINCIPAL-080
3 x PANNEAU_MR_PRINCIPAL-081
3 x PANNEAU_MR_PRINCIPAL-082
3 x PANNEAU_MR_PRINCIPAL-083
3 x PANNEAU_MR_PRINCIPAL-084
3 x PANNEAU_MR_PRINCIPAL-085
3 x PANNEAU_MR_PRINCIPAL-086
3 x PANNEAU_MR_PRINCIPAL-087
3 x PANNEAU_MR_PRINCIPAL-088
3 x PANNEAU_MR_PRINCIPAL-089
3 x PANNEAU_MR_PRINCIPAL-090
3 x PANNEAU_MR_PRINCIPAL-091
3 x PANNEAU_MR_PRINCIPAL-092
3 x PANNEAU_MR_PRINCIPAL-093
3 x PANNEAU_MR_PRINCIPAL-094
3 x PANNEAU_MR_PRINCIPAL-095
3 x PANNEAU_MR_PRINCIPAL-096
3 x PANNEAU_MR_PRINCIPAL-097
3 x PANNEAU_MR_PRINCIPAL-098
3 x PANNEAU_MR_PRINCIPAL-099
3 x PANNEAU_MR_PRINCIPAL-100
3 x PANNEAU_MR_PRINCIPAL-101
2 x PANNEAU_MR_PRINCIPAL-102
2 x PANNEAU_MR_PRINCIPAL-103
2 x PANNEAU_MR_PRINCIPAL-104
2 x PANNEAU_MR_PRINCIPAL-105
2 x PANNEAU_MR_PRINCIPAL-106
2 x PANNEAU_MR_PRINCIPAL-107
2 x PANNEAU_MR_PRINCIPAL-108
2 x PANNEAU_MR_PRINCIPAL-109
2 x PANNEAU_MR_PRINCIPAL-110
2 x PANNEAU_MR_PRINCIPAL-111
2 x PANNEAU_MR_PRINCIPAL-112
2 x PANNEAU_MR_PRINCIPAL-113
2 x PANNEAU_MR_PRINCIPAL-114
2 x PANNEAU_MR_PRINCIPAL-115
2 x PANNEAU_MR_PRINCIPAL-116
2 x PANNEAU_MR_PRINCIPAL-117
2 x PANNEAU_MR_PRINCIPAL-118
2 x PANNEAU_MR_PRINCIPAL-119
2 x PANNEAU_MR_PRINCIPAL-120
2 x PANNEAU_MR_PRINCIPAL-121
2 x PANNEAU_MR_PRINCIPAL-122
2 x PANNEAU_MR_PRINCIPAL-124
2 x PANNEAU_MR_PRINCIPAL-125
2 x PANNEAU_MR_PRINCIPAL-126
2 x PANNEAU_MR_PRINCIPAL-127
2 x PANNEAU_MR_PRINCIPAL-128
2 x PANNEAU_MR_PRINCIPAL-129
2 x PANNEAU_MR_PRINCIPAL-130
2 x PANNEAU_MR_PRINCIPAL-131
2 x PANNEAU_MR_PRINCIPAL-132
2 x PANNEAU_MR_PRINCIPAL-133
2 x PANNEAU_MR_PRINCIPAL-134
2 x PANNEAU_MR_PRINCIPAL-135
2 x PANNEAU_MR_PRINCIPAL-136
2 x PANNEAU_MR_PRINCIPAL-137
2 x PANNEAU_MR_PRINCIPAL-138
2 x PANNEAU_MR_PRINCIPAL-139
2 x PANNEAU_MR_PRINCIPAL-140
2 x PANNEAU_MR_PRINCIPAL-141
2 x PANNEAU_MR_PRINCIPAL-142
2 x PANNEAU_MR_PRINCIPAL-143
2 x PANNEAU_MR_PRINCIPAL-144
2 x PANNEAU_MR_PRINCIPAL-145
2 x PANNEAU_MR_PRINCIPAL-146
2 x PANNEAU_MR_PRINCIPAL-147
2 x PANNEAU_MR_PRINCIPAL-148
2 x PANNEAU_MR_PRINCIPAL-149
2 x PANNEAU_MR_PRINCIPAL-150
2 x PANNEAU_MR_PRINCIPAL-151
2 x PANNEAU_MR_PRINCIPAL-152
2 x PANNEAU_MR_PRINCIPAL-153
2 x PANNEAU_MR_PRINCIPAL-154
2 x PANNEAU_MR_PRINCIPAL-155
2 x PANNEAU_MR_PRINCIPAL-156
2 x PANNEAU_MR_PRINCIPAL-157
2 x PANNEAU_MR_PRINCIPAL-158
2 x PANNEAU_MR_PRINCIPAL-159
2 x PANNEAU_MR_PRINCIPAL-160
2 x PANNEAU_MR_PRINCIPAL-161
2 x PANNEAU_MR_PRINCIPAL-162
2 x PANNEAU_MR_PRINCIPAL-163
2 x PANNEAU_MR_PRINCIPAL-164
2 x PANNEAU_MR_PRINCIPAL-165
2 x PANNEAU_MR_PRINCIPAL-166
2 x PANNEAU_MR_PRINCIPAL-167
2 x PANNEAU_MR_PRINCIPAL-168
2 x PANNEAU_MR_PRINCIPAL-169

# IfcBuildingElementProxy: Panneau principal 25 x 2888 x 25 (65)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-168
PANNEAU_MR_PRINCIPAL-169
PANNEAU_MR_PRINCIPAL-170
PANNEAU_MR_PRINCIPAL-171
PANNEAU_MR_PRINCIPAL-172
PANNEAU_MR_PRINCIPAL-173
PANNEAU_MR_PRINCIPAL-174
PANNEAU_MR_PRINCIPAL-175
PANNEAU_MR_PRINCIPAL-176
PANNEAU_MR_PRINCIPAL-177
PANNEAU_MR_PRINCIPAL-178
PANNEAU_MR_PRINCIPAL-179
PANNEAU_MR_PRINCIPAL-180
PANNEAU_MR_PRINCIPAL-181
PANNEAU_MR_PRINCIPAL-182
PANNEAU_MR_PRINCIPAL-183
PANNEAU_MR_PRINCIPAL-184
PANNEAU_MR_PRINCIPAL-185
PANNEAU_MR_PRINCIPAL-186
PANNEAU_MR_PRINCIPAL-187
PANNEAU_MR_PRINCIPAL-188
PANNEAU_MR_PRINCIPAL-189
PANNEAU_MR_PRINCIPAL-190
PANNEAU_MR_PRINCIPAL-191
PANNEAU_MR_PRINCIPAL-192
PANNEAU_MR_PRINCIPAL-193
PANNEAU_MR_PRINCIPAL-194
PANNEAU_MR_PRINCIPAL-195
PANNEAU_MR_PRINCIPAL-196
PANNEAU_MR_PRINCIPAL-197
PANNEAU_MR_PRINCIPAL-198
PANNEAU_MR_PRINCIPAL-199
PANNEAU_MR_PRINCIPAL-200
PANNEAU_MR_PRINCIPAL-201
PANNEAU_MR_PRINCIPAL-202
PANNEAU_MR_PRINCIPAL-203
PANNEAU_MR_PRINCIPAL-204
PANNEAU_MR_PRINCIPAL-205
PANNEAU_MR_PRINCIPAL-206
PANNEAU_MR_PRINCIPAL-207
PANNEAU_MR_PRINCIPAL-208
PANNEAU_MR_PRINCIPAL-209
PANNEAU_MR_PRINCIPAL-210
PANNEAU_MR_PRINCIPAL-211
PANNEAU_MR_PRINCIPAL-212
PANNEAU_MR_PRINCIPAL-213
PANNEAU_MR_PRINCIPAL-214
PANNEAU_MR_PRINCIPAL-215
PANNEAU_MR_PRINCIPAL-216
PANNEAU_MR_PRINCIPAL-217
PANNEAU_MR_PRINCIPAL-218
PANNEAU_MR_PRINCIPAL-219
PANNEAU_MR_PRINCIPAL-220
PANNEAU_MR_PRINCIPAL-221
PANNEAU_MR_PRINCIPAL-222
PANNEAU_MR_PRINCIPAL-223
PANNEAU_MR_PRINCIPAL-224
PANNEAU_MR_PRINCIPAL-225
PANNEAU_MR_PRINCIPAL-226
PANNEAU_MR_PRINCIPAL-227
PANNEAU_MR_PRINCIPAL-228
PANNEAU_MR_PRINCIPAL-229
PANNEAU_MR_PRINCIPAL-230
PANNEAU_MR_PRINCIPAL-231
PANNEAU_MR_PRINCIPAL-232

# IfcBuildingElementProxy: Panneau principal 25 x 900 x 25 (252)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
4 x PANNEAU_MR_PRINCIPAL-124
4 x PANNEAU_MR_PRINCIPAL-125
4 x PANNEAU_MR_PRINCIPAL-126
4 x PANNEAU_MR_PRINCIPAL-127
4 x PANNEAU_MR_PRINCIPAL-128
4 x PANNEAU_MR_PRINCIPAL-129
4 x PANNEAU_MR_PRINCIPAL-130
4 x PANNEAU_MR_PRINCIPAL-131
4 x PANNEAU_MR_PRINCIPAL-132
4 x PANNEAU_MR_PRINCIPAL-133
4 x PANNEAU_MR_PRINCIPAL-134
4 x PANNEAU_MR_PRINCIPAL-135
4 x PANNEAU_MR_PRINCIPAL-136
4 x PANNEAU_MR_PRINCIPAL-137
4 x PANNEAU_MR_PRINCIPAL-138
4 x PANNEAU_MR_PRINCIPAL-139
4 x PANNEAU_MR_PRINCIPAL-140
4 x PANNEAU_MR_PRINCIPAL-141
4 x PANNEAU_MR_PRINCIPAL-142
4 x PANNEAU_MR_PRINCIPAL-143
4 x PANNEAU_MR_PRINCIPAL-144
4 x PANNEAU_MR_PRINCIPAL-145
4 x PANNEAU_MR_PRINCIPAL-146
4 x PANNEAU_MR_PRINCIPAL-147
4 x PANNEAU_MR_PRINCIPAL-148
4 x PANNEAU_MR_PRINCIPAL-149
4 x PANNEAU_MR_PRINCIPAL-150
4 x PANNEAU_MR_PRINCIPAL-151
4 x PANNEAU_MR_PRINCIPAL-152
4 x PANNEAU_MR_PRINCIPAL-153
4 x PANNEAU_MR_PRINCIPAL-154
4 x PANNEAU_MR_PRINCIPAL-155
4 x PANNEAU_MR_PRINCIPAL-156
4 x PANNEAU_MR_PRINCIPAL-157
4 x PANNEAU_MR_PRINCIPAL-158
4 x PANNEAU_MR_PRINCIPAL-159
4 x PANNEAU_MR_PRINCIPAL-160
4 x PANNEAU_MR_PRINCIPAL-161
4 x PANNEAU_MR_PRINCIPAL-162
4 x PANNEAU_MR_PRINCIPAL-163
4 x PANNEAU_MR_PRINCIPAL-164
4 x PANNEAU_MR_PRINCIPAL-165
PANNEAU_MR_PRINCIPAL-253
PANNEAU_MR_PRINCIPAL-254
PANNEAU_MR_PRINCIPAL-255
PANNEAU_MR_PRINCIPAL-256
PANNEAU_MR_PRINCIPAL-257
PANNEAU_MR_PRINCIPAL-258
PANNEAU_MR_PRINCIPAL-259
PANNEAU_MR_PRINCIPAL-260
PANNEAU_MR_PRINCIPAL-261
PANNEAU_MR_PRINCIPAL-262
PANNEAU_MR_PRINCIPAL-263
PANNEAU_MR_PRINCIPAL-264
PANNEAU_MR_PRINCIPAL-265
PANNEAU_MR_PRINCIPAL-266
PANNEAU_MR_PRINCIPAL-267
PANNEAU_MR_PRINCIPAL-268
PANNEAU_MR_PRINCIPAL-269
PANNEAU_MR_PRINCIPAL-270
PANNEAU_MR_PRINCIPAL-271
PANNEAU_MR_PRINCIPAL-272
PANNEAU_MR_PRINCIPAL-273
PANNEAU_MR_PRINCIPAL-274
PANNEAU_MR_PRINCIPAL-275
PANNEAU_MR_PRINCIPAL-276
PANNEAU_MR_PRINCIPAL-277
PANNEAU_MR_PRINCIPAL-278
PANNEAU_MR_PRINCIPAL-279
PANNEAU_MR_PRINCIPAL-280
PANNEAU_MR_PRINCIPAL-281
PANNEAU_MR_PRINCIPAL-282
PANNEAU_MR_PRINCIPAL-283
PANNEAU_MR_PRINCIPAL-284
PANNEAU_MR_PRINCIPAL-285
PANNEAU_MR_PRINCIPAL-286
PANNEAU_MR_PRINCIPAL-287
PANNEAU_MR_PRINCIPAL-288
PANNEAU_MR_PRINCIPAL-289
PANNEAU_MR_PRINCIPAL-290
PANNEAU_MR_PRINCIPAL-291
PANNEAU_MR_PRINCIPAL-292
PANNEAU_MR_PRINCIPAL-293
PANNEAU_MR_PRINCIPAL-294
PANNEAU_MR_PRINCIPAL-210
PANNEAU_MR_PRINCIPAL-211
PANNEAU_MR_PRINCIPAL-212
PANNEAU_MR_PRINCIPAL-213
PANNEAU_MR_PRINCIPAL-214
PANNEAU_MR_PRINCIPAL-215
PANNEAU_MR_PRINCIPAL-216
PANNEAU_MR_PRINCIPAL-217
PANNEAU_MR_PRINCIPAL-218
PANNEAU_MR_PRINCIPAL-219
PANNEAU_MR_PRINCIPAL-220
PANNEAU_MR_PRINCIPAL-221
PANNEAU_MR_PRINCIPAL-222
PANNEAU_MR_PRINCIPAL-223
PANNEAU_MR_PRINCIPAL-224
PANNEAU_MR_PRINCIPAL-225
PANNEAU_MR_PRINCIPAL-226
PANNEAU_MR_PRINCIPAL-227
PANNEAU_MR_PRINCIPAL-228
PANNEAU_MR_PRINCIPAL-229
PANNEAU_MR_PRINCIPAL-230
PANNEAU_MR_PRINCIPAL-231
PANNEAU_MR_PRINCIPAL-232
PANNEAU_MR_PRINCIPAL-233
PANNEAU_MR_PRINCIPAL-234
PANNEAU_MR_PRINCIPAL-235
PANNEAU_MR_PRINCIPAL-236
PANNEAU_MR_PRINCIPAL-237
PANNEAU_MR_PRINCIPAL-238
PANNEAU_MR_PRINCIPAL-239
PANNEAU_MR_PRINCIPAL-240
PANNEAU_MR_PRINCIPAL-241
PANNEAU_MR_PRINCIPAL-242
PANNEAU_MR_PRINCIPAL-243
PANNEAU_MR_PRINCIPAL-244
PANNEAU_MR_PRINCIPAL-245
PANNEAU_MR_PRINCIPAL-246
PANNEAU_MR_PRINCIPAL-247
PANNEAU_MR_PRINCIPAL-248
PANNEAU_MR_PRINCIPAL-249
PANNEAU_MR_PRINCIPAL-250
PANNEAU_MR_PRINCIPAL-251

# IfcBuildingElementProxy: Panneau principal 30 x 900 x 25 (6)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
4 x PANNEAU_MR_PRINCIPAL-123
PANNEAU_MR_PRINCIPAL-252
PANNEAU_MR_PRINCIPAL-209

# IfcBuildingElementProxy: Panneau principal 7 x 2588 x 25 (2)
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 7 x 2888 x 25, PANNEAU_MR_PRINCIPAL-167
In: 0. Étage
Material: Bois - Massif Bardage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 877 x 2387 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini

# IfcBuildingElementProxy: Panneau principal 996 x 1027 x 32 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Non défini
Name
PANNEAU_MR_PRINCIPAL-501
PANNEAU_MR_PRINCIPAL-512

# IfcBuildingElementProxy: Plastique - Caoutchouc, TER-007
In: 1. Étage
Material: Plastique - Caoutchouc
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Plastique - PVC blanc 5 (9)
In: -1. Étage
Material: Plastique - PVC blanc
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte ext générique_v2017 (6)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Porte int générique_v2017 (40)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
8 x P93n | 0. Étage
13 x P93s | 0. Étage
19 x P93n | 1. Étage

# IfcBuildingElementProxy: S01 - Sol souple sur chape : 7 70 (2)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
Chape_sol | 0. Étage
Chape_sol | 1. Étage

# IfcBuildingElementProxy: Series [e] PL63 PTR FBF (6)
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Sigma 170 56 x 170 (27)
In: 2. Étage
Material: Métal - Galavanisé
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Struct. - B.A. coulé (2)
In: 0. Étage
Material: Struct. - B.A. coulé
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Struct. - Béton préfabriqué +++ 150 x 310 (6)
In: -1. Étage
Material: Struct. - Béton préfabriqué +++
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
2 x PoBA-008
4 x PoBA-010

# IfcBuildingElementProxy: Struct. - Béton préfabriqué +++ 150 x 370, PoBA-010
In: -1. Étage
Material: Struct. - Béton préfabriqué +++
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Struct. - Béton préfabriqué +++ 150 x 450 (13)
In: -1. Étage
Material: Struct. - Béton préfabriqué +++
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
8 x PoBA-010
PoBA-009
3 x PoBA-008
PoBA-007

# IfcBuildingElementProxy: Structures diverses - 2 Segments - 60 x 140 x 2780 (10+2770) (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Structures diverses - 2 Segments - 60 x 140 x 2790 (10+2780) (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Structures diverses - 2 Segments - 60 x 140 x 6174 (10+6164) (8)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Structures diverses - 3 Segments - 82 x 160 x 764 (15+739+10) (6)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Structures diverses - 4 Segments - 2600 x 2600 x 3110 (2000+500+600+10) (25)
In: -1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Structures diverses - 7 Segments - 190 x 850 x 11654 (79+857+20+9698+20+900+79) (2)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Structures diverses - 7 Segments - 190 x 850 x 14661 (79+857+20+12705+20+900+79) (12)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Structures diverses - 7 Segments - 190 x 850 x 14662 (79+857+20+12705+20+900+80) (14)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Structures diverses - 7 Segments - 310 x 950 x 5738 (30+200+4591+20+20+819+58) (26)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Structures diverses - 7 Segments - 310 x 950 x 5948 (30+200+4801+20+20+819+58) (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: T01-Couverture : bac acier 40 mm + iso 120 mm Lr + bitume 168 (2)
In: 2. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Type d'escalier, ESCALIER-01
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Type de garde-corps (5)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
3 x RAMPE-007
2 x GARDE_CORPS-005

# IfcBuildingElementProxy: Type de mur-rideau (18)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
17 x MUR_RIDEAU-003
MUR_RIDEAU-002

# IfcBuildingElementProxy: Tête de mur retournée 25 (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: UPN140 60 x 140 (4)
In: 1. Étage
Material: Métal - Strcuture métal
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: V00-Enrobé PL 220 (58)
In: -1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
2 x Toit-05
Toit-43
Toit-44
15 x Toit-03
2 x Toit-04
Toit-45
Toit-07
Toit-08
Toit-09
Toit-10
Toit-11
Toit-12
Toit-13
Toit-14
Toit-15
Toit-16
Toit-17
Toit-18
Toit-19
Toit-20
Toit-21
Toit-22
Toit-23
Toit-24
Toit-25
Toit-26
Toit-27
Toit-28
Toit-29
Toit-30
Toit-31
Toit-32
Toit-33
Toit-34
Toit-35
Toit-36
Toit-37
Toit-38
Toit-39
Toit-40
Toit-41
Toit-42

# IfcBuildingElementProxy: VRD00-béton balayer 330, Toit-03
In: -1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: WC 25 (8)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
7 x WC | 0. Étage
WC | 1. Étage

# IfcBuildingElementProxy: brama_przesuwna_robusta (2)
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: iMac 25 (6)
In: 1. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: intra_icon_wall_mounted_toilet_paper_holder (8)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
7 x TERREAL_DC14_Cathedrale | 0. Étage
TERREAL_DC14_Cathedrale | 1. Étage

# IfcBuildingElementProxy: intra_millinox_wall_mounted_toilet_brush_holder (8)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
7 x TERREAL_DC14_Cathedrale | 0. Étage
TERREAL_DC14_Cathedrale | 1. Étage

# IfcOpeningElement (125)
Name | In
2 x Tête de cloison | 0. Étage
22 x FOF96/155 | 0. Étage
6 x P94 | 0. Étage
6 x F12 OB | 0. Étage
14 x Ff586/120 | 0. Étage
8 x P93n | 0. Étage
13 x P93s | 0. Étage
5 x PSECT320/450_QV | 0. Étage
4 x PERCEMENT-001 | 0. Étage | AC_Pset_RenovationAndPhasing - Renovation Status: Existing
19 x P93n | 1. Étage
18 x Ff586/120 | 1. Étage
8 x Fenêtre de toit motorisée 94 x 98 - intègré | 2. Étage
